# Keil uVision project CarTest1.uvprojx, settings and files
target CarTest1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CarTest1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,NDEBUG,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User;../User/my_lib;../User/LCD;../User/lvgl;../User/lvgl/src;../User/lvgl/porting;../User/GUI;../User/GUI/lvgl;../User/GUI/lvgl/example;../User/GUI/lvgl/example/porting;../User/GUI/lvgl/src;../User/GUI/GUI_test/demos;../User/GUI/GUI_test/demos/stress;../User/GUI/GUI_test/demos/benchmark;../User/GUI/GUI_test/my_gui;../User/wit_c_sdk;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../User/GUI/GUI_test;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;..\Drivers\CMSIS\DSP\Include
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fsmc.c iwdg.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: arm_dot_prod_f32.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group user
    ../User/GUI/lvgl/: lv_conf.h
    ../User/: my_sys.c
    ../User/my_lib/: button.c led.c vofa_communication.c motor.c car_ctrl.c my_log.c file_info.c route.c step_motor.c steer.c arm.c rgb.c communication.c remote_ctrl.c step_trape.c m_shell.c QR_code.c beep.c
    ../User/LCD/: common.c lcd.c xpt2046.c
    ../User/wit_c_sdk/: wit_c_sdk.c jy901.c
    ../User/my_task/: my_task.c
    ../User/GUI/GUI_test/my_gui/: my_gui.c ui_events.c ui.c ui_helpers.c
    ../User/cJson/: cJSON.c
    ../User/GUI/GUI_test/my_gui/screens/: ui_ScreenMenu.c ui_ScreenArm.c ui_ScreenTask.c ui_Screen1.c ui_ScreenCFIG.c
    ../User/GUI/GUI_test/my_gui/fonts/: ui_font_bigNum.c
  group lvgl/example/porting
    ../User/GUI/lvgl/example/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group lvgl/src/core
    ../User/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../User/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../User/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../User/GUI/lvgl/src/extra/: lv_extra.c
    ../User/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../User/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../User/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../User/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../User/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../User/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../User/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../User/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../User/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../User/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../User/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../User/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../User/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../User/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../User/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../User/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../User/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../User/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../User/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../User/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../User/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../User/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../User/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../User/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../User/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../User/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../User/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../User/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../User/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../User/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../User/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../User/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../User/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group lvgl/src/font
    ../User/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ../User/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../User/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/hal
    ../User/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../User/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../User/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
